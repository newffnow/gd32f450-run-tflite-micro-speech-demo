# Keil uVision project keil_project.uvprojx, settings and files
target hello_world_test (6120000::V6.12::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: hello_world_test
  c flags: Optim=7 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .;third_party/gemmlowp;third_party/flatbuffers/include;third_party/ruy;third_party/kissfft
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: LICENSE
    tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.c common.h
    tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h tensor_utils.cc tensor_utils.h
    tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.cc quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
    tensorflow/lite/kernels/internal/optimized/: neon_check.h
    tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_matmul.h batch_to_space_nd.h binary_function.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.cc portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
    tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mean.h mul.h pooling.h tanh.h transpose_conv.h
    tensorflow/lite/kernels/: kernel_util.cc kernel_util.h op_macros.h padding.h
    tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h compatibility.h debug_log.cc debug_log.h flatbuffer_utils.cc flatbuffer_utils.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_graph.cc micro_graph.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cc micro_profiler.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h mock_micro_graph.cc mock_micro_graph.h recording_micro_allocator.cc recording_micro_allocator.h recording_micro_interpreter.h recording_simple_memory_allocator.cc recording_simple_memory_allocator.h simple_memory_allocator.cc simple_memory_allocator.h system_setup.cc system_setup.h test_helpers.cc test_helpers.h
    tensorflow/lite/micro/benchmarks/: keyword_scrambled_model_data.h
    tensorflow/lite/micro/examples/hello_world/: hello_world_test.cc
    tensorflow/lite/micro/kernels/: activation_utils.h activations.cc activations.h activations_common.cc add.cc add_n.cc arg_min_max.cc batch_to_space_nd.cc cast.cc ceil.cc circular_buffer.cc circular_buffer.h circular_buffer_common.cc circular_buffer_flexbuffers_generated_data.h comparisons.cc concatenation.cc conv.cc conv.h conv_common.cc conv_test.h cumsum.cc depth_to_space.cc depthwise_conv.cc depthwise_conv.h depthwise_conv_common.cc dequantize.cc detection_postprocess.cc detection_postprocess_flexbuffers_generated_data.h elementwise.cc elu.cc ethosu.cc ethosu.h exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected.cc fully_connected.h fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc hard_swish.h hard_swish_common.cc if.cc kernel_runner.cc kernel_runner.h kernel_util.cc kernel_util.h l2_pool_2d.cc l2norm.cc leaky_relu.cc leaky_relu.h leaky_relu_common.cc log_softmax.cc logical.cc logical.h logical_common.cc logistic.cc logistic.h logistic_common.cc maximum_minimum.cc micro_ops.h micro_utils.h mul.cc neg.cc pack.cc pad.cc pooling.cc pooling.h pooling_common.cc prelu.cc quantize.cc quantize.h quantize_common.cc reduce.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc round.cc shape.cc softmax.cc softmax.h softmax_common.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squeeze.cc strided_slice.cc sub.cc svdf.cc svdf.h svdf_common.cc tanh.cc transpose.cc transpose_conv.cc unpack.cc zeros_like.cc
    tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_planner.h
    tensorflow/lite/micro/testing/: micro_test.h test_conv_model.h
    tensorflow/lite/: portable_type_to_tflitetype.h
    tensorflow/lite/schema/: schema_generated.h schema_utils.cc schema_utils.h
    third_party/flatbuffers/: LICENSE.txt
    third_party/flatbuffers/include/flatbuffers/: base.h flatbuffers.h flexbuffers.h stl_emulation.h util.h
    third_party/gemmlowp/: LICENSE
    third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_neon.h fixedpoint_sse.h
    third_party/gemmlowp/internal/: detect_platform.h
    third_party/kissfft/: COPYING _kiss_fft_guts.h kiss_fft.h
    third_party/kissfft/tools/: kiss_fftr.h
    third_party/ruy/ruy/profiler/: instrumentation.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
