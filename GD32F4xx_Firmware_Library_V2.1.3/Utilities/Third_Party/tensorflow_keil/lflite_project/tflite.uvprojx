# Keil uVision project tflite.uvprojx, settings and files
target tensoflow_lite_mirco_lib (6160000::V6.16::ARMCLANG)
  device: GD32F450ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tflite (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG
  c include: ..\third_party\gemmlowp;..\third_party\flatbuffers\include;..\third_party\ruy;..\third_party\kissfft;..\..\tensorflow_keil
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group tensoflow/lite/c
    ../tensorflow/lite/c/: common.c
  group tensoflow_lite/core
    ../tensorflow/lite/core/api/: error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
  group tensoflow_lite/kernel
    ../tensorflow/lite/kernels/: kernel_util.cc
    ../tensorflow/lite/kernels/internal/: quantization_util.cc
    ../tensorflow/lite/kernels/internal/reference/: portable_tensor_utils.cc
  group tensoflow_lite/mirco
    ../tensorflow/lite/micro/: all_ops_resolver.cc debug_log.cc flatbuffer_utils.cc memory_helpers.cc micro_allocator.cc micro_error_reporter.cc micro_graph.cc micro_interpreter.cc micro_profiler.cc micro_string.cc micro_time.cc micro_utils.cc mock_micro_graph.cc recording_micro_allocator.cc recording_simple_memory_allocator.cc simple_memory_allocator.cc system_setup.cc test_helpers.cc
  group tensoflow_lite/mirco/kernel
    ../tensorflow/lite/micro/kernels/: activations.cc activations_common.cc add.cc add_n.cc arg_min_max.cc batch_to_space_nd.cc cast.cc ceil.cc circular_buffer.cc circular_buffer_common.cc comparisons.cc concatenation.cc conv.cc conv_common.cc cumsum.cc depth_to_space.cc depthwise_conv.cc depthwise_conv_common.cc dequantize.cc detection_postprocess.cc elementwise.cc elu.cc ethosu.cc exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected.cc fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc hard_swish_common.cc if.cc kernel_runner.cc l2_pool_2d.cc l2norm.cc leaky_relu.cc leaky_relu_common.cc log_softmax.cc logical.cc logical_common.cc logistic.cc logistic_common.cc maximum_minimum.cc mul.cc neg.cc pack.cc pad.cc pooling.cc pooling_common.cc prelu.cc quantize.cc quantize_common.cc reduce.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc round.cc shape.cc softmax.cc softmax_common.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squeeze.cc strided_slice.cc sub.cc svdf.cc svdf_common.cc tanh.cc transpose.cc transpose_conv.cc unpack.cc zeros_like.cc kernel_util.cc
  group tensoflow_lite/memory
    ../tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc
  group tensoflow_lite/sch
    ../tensorflow/lite/schema/: schema_utils.cc
